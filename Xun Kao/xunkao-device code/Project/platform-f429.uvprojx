# Keil uVision project platform-f429.uvprojx, settings and files
target PlatForm (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: platform-f429 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,__free_rtos__
  c include: ..\Mcu\stm32f429ig\STM32F4xx_HAL_Driver\Inc;..\Mcu\stm32f429ig\CMSIS\Include;..\Mcu\stm32f429ig\CMSIS\Device\ST\STM32F4xx\Include;..\User\config;..\User;..;..\Elab;..\User\driver;..\Elab\3rd\FreeRTOS\include;..\Elab\3rd\FreeRTOS\port\RVDS\ARM_CM4F;..\Elab\3rd\Qpc\include;..\Elab\3rd\LwIP\include;..\Elab\3rd\LwIP\include\lwip;..\Elab\3rd\LwIP\include\compat;..\Elab\3rd\LwIP\include\netif;..\Elab\3rd\LwIP\include\lwip\apps;..\Elab\3rd\LwIP\include\lwip\priv;..\Elab\3rd\LwIP\include\lwip\prot;..\User\arch;..\Elab\3rd\cJSON
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0xd0000000 size 0x2000000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\platform-f429.sct
  group User.App
    ../User/: main.c
    ../User/app/: data_parse.c app.c net_client.c operater.c
  group User.Bsp
    ../User/bsp/: bsp.c elab_uart_debug.c bsp_eth.c bsp_sdram.c
  group User.Export
    ../User/export/: shell_export.c pin_export.c button_export.c led_export.c watchdog_export.c rtc_export.c adc_export.c serial.export.c pwm_in_export.c
  group User.Driver
    ../User/driver/: drv_pwm_in.c drv_pin_mcu.c drv_button_pin.c drv_watchdog.c drv_rtc.c drv_serial.c drv_adc.c drv_util.c
  group User.Config
    ../User/config/: stm32f4xx_hal_conf.h elab_config.h FreeRTOSConfig.h event_def.h
    ../User/arch/: lwipopts.h
  group User.Test
    ../User/test/: test_led.c test_key.c test_watchdog.c test.serial.c test_rtc.c test_adc.c test_qpc.c test_pwm_in.c test_operater.c
  group MCU
    ../User/bsp/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f429xx.s
  group HAL
    ../Mcu/stm32f429ig/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_ll_dma.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_eth.c stm32f4xx_hal_sdram.c stm32f4xx_ll_fmc.c
  group Elab.common
    ../Elab/common/: elab_common.c elab_assert.c elab_export.c elab_log.c
    ../Elab/elib/: elib_queue.c
  group Elab.edf
    ../Elab/edf/: elab_device.c
    ../Elab/edf/normal/: elab_pin.c elab_adc.c elab_rtc.c elab_watchdog.c elab_serial.c elab_pwm_in.c
    ../Elab/edf/user/: elab_led.c elab_button.c elab_rsxxx.c
  group Elab.test
    ../Elab/test/: test_pin.c
  group Elab.3rd.shell
    ../Elab/3rd/Shell/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c
  group Elab.3rd.FreeRTOS
    ../Elab/os/mcu/: cmsis_os2.c
    ../Elab/3rd/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Elab/3rd/FreeRTOS/port/MemMang/: heap_4.c
    ../Elab/3rd/FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group Elab.3rd.Qpc
    ../Elab/3rd/Qpc/: qpc_export.c
    ../Elab/3rd/Qpc/src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../Elab/3rd/Qpc/ports/freertos/: qf_port.c
  group Elab.3rd.LwIP.api
    ../Elab/3rd/LwIP/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Elab.3rd.LwIP.core
    ../Elab/3rd/LwIP/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Elab/3rd/LwIP/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Elab.3rd.LwIP.netif
    ../Elab/3rd/LwIP/netif/: ethernet.c bridgeif.c lowpan6.c lowpan6_ble.c lowpan6_common.c zepif.c
  group Elab.3rd.LwIP.arch
    ../User/arch/: sys_arch.c ethernetif.c
  group Elab.3rd.CJson
    ../Elab/3rd/cJSON/: cJSON.c
